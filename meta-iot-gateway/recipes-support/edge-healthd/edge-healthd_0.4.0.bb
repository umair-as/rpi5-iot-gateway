require edge-healthd.inc

# Pin upstream source for reproducible non-externalsrc builds.
SRCREV = "522332a5defcdd15e604e2f4fbe4c6d2b87d87ad"

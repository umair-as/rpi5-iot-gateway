require edge-healthd.inc

# Pin upstream source for reproducible non-externalsrc builds.
SRCREV = "78b53a464e3c4d5b98f0fabdf91abc5728cd4ae7"

# CVE-2023-0361: timing side channel in RSA-PSK key exchange; the upstream NEWS
# of the shipped tarball lists the fix under "Version 3.8.0".
CVE_STATUS[CVE-2023-0361] = "fixed-version: fixed in 3.8.0 (upstream NEWS)"

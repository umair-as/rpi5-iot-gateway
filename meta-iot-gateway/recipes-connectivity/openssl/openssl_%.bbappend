# CVE-2015-3216: the CVE record scopes the flaw to a Red Hat downstream patch
# (ssleay_rand_bytes locking); that function does not exist in OpenSSL 3.x.
CVE_STATUS[CVE-2015-3216] = "not-applicable-platform: flaw in a Red Hat downstream patch (ssleay_rand_bytes); function absent from 3.x"

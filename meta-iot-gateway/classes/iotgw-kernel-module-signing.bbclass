# Verify that out-of-tree kernel modules are signed with the key this kernel
# trusts. VERIFIES — it does not sign. Read the next paragraph before changing
# that.
#
# ONE SIGNING AUTHORITY: KBUILD
# This distro builds every image with CONFIG_MODULE_SIG_FORCE=y and
# CONFIG_MODULE_SIG_ALL=y (security-prod.cfg via igw_security_prod, which is in
# the default IOTGW_KERNEL_FEATURES). Confirmed on target: sig_enforce=Y.
#
# CONFIG_MODULE_SIG_ALL makes Kbuild sign modules during `modules_install` —
# and that includes EXTERNAL modules, because an out-of-tree recipe's install
# step routes through Kbuild. Verified for dx-driver against its real Makefile:
#
#     modules/Makefile:74
#       install:
#               $(MAKE) -C $(KERNEL_DIR) M=$(MODULE_DIR) ... modules_install
#
# So the .ko is already signed by the time do_install finishes. An earlier
# version of this class signed it a SECOND time with sign-file. That was wrong:
# two signing authorities for one artifact, with no one owning the outcome.
# Kbuild is the authority; this class is the gate that proves Kbuild did its
# job, so a packaging change that silently bypasses modules_install fails the
# build instead of shipping an unloadable module.
#
# If a recipe ever installs .ko files WITHOUT going through modules_install,
# this class will fail it — correctly. The fix then is to route that recipe
# through modules_install, not to add a second signer here.
#
# USAGE
#   inherit iotgw-kernel-module-signing
#
# KEY PROVENANCE
# Without IOTGW_MODULE_SIG_KEY_FILE the kernel signs with a key it generates at
# build time ("signer: Build time autogenerated kernel key" on target),
# regenerated whenever certs/signing_key.pem is absent, so modules signed
# against build N do not load on a kernel from build N+1.
#
# iotgw-kernel-module-sig-key.bbclass wires CONFIG_MODULE_SIG_KEY to a
# persistent operator-held key when IOTGW_MODULE_SIG_KEY_FILE is set
# (kas/local.yml). It is OPT-IN — with the variable unset the auto-generated-key
# behaviour above is still what you get, so read the running config before
# assuming which applies. Confirm on target with `modinfo -F signer <mod>`,
# which names the key.
#
# Pairing and key custody:
#  - Key: IOTGW_MODULE_SIG_KEY_FILE gives a persistent operator-held key
#    (iotgw-kernel-module-sig-key.bbclass), a plain file on the build host: lab
#    posture; HSM/YubiKey custody (docs/FIT_BOOT_SIGNING.md) is not wired.
#  - Pairing: every bundle is a full FIT bundle (runtime dm-verity); the
#    bootfiles archive recipe fails unless it can write kernel.release, and the
#    bundle hook refuses an archive without it or any release that differs from
#    the new slot's /lib/modules.
#  - sstate: the key file is in do_configure[file-checksums], so a key change
#    changes the kernel and every module taskhash. This covers the key
#    changing, not a proof that every sstate object used the current key.

inherit module

IOTGW_MODULE_SIG_MAGIC ?= "~Module signature appended~"

do_install[vardeps] += "IOTGW_MODULE_SIG_MAGIC"

do_install:append() {
    iotgw_verify_kernel_module_signatures
}

iotgw_verify_kernel_module_signatures() {
    found=0
    unsigned=""
    for ko in $(find "${D}" -type f -name '*.ko'); do
        found=$(expr $found + 1)
        # A signed module ends with EXACTLY this 28-byte trailer
        # (27 chars + newline). Compare at the exact offset rather than
        # grepping a window near EOF: a substring search would also pass on a
        # module that merely CONTAINS the text somewhere in its tail, which
        # proves proximity, not a well-formed signature.
        if [ "$(tail -c 28 "$ko" | tr -d '\n')" != "${IOTGW_MODULE_SIG_MAGIC}" ]; then
            unsigned="$unsigned $ko"
        fi
    done

    if [ "$found" -eq 0 ]; then
        bbfatal "module signature check: no .ko files found under ${D}." \
                "Either the module did not build or its install path changed;" \
                "passing silently here would ship an unusable package."
    fi

    if [ -n "$unsigned" ]; then
        bbfatal "module signature check: UNSIGNED module(s):$unsigned" \
                "This kernel runs CONFIG_MODULE_SIG_FORCE=y, so these would" \
                "install correctly and then fail to load with EKEYREJECTED." \
                "Expected Kbuild's CONFIG_MODULE_SIG_ALL to sign them during" \
                "modules_install — check that this recipe's install target" \
                "actually routes through modules_install."
    fi

    bbnote "module signature check: $found module(s) carry a signature trailer"
}

require tpm-ops.inc

# Pin upstream source for reproducible non-externalsrc builds.
SRCREV = "6ec22b470c2df68b1a4dadeb3bf92431919a8b12"

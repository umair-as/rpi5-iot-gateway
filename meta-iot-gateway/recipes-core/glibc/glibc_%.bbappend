# CVE_STATUS — narrowly-evidenced VEX for sbom-cve-check matches.
#
# CVE-2011-0536: $ORIGIN/DST handling; upstream glibc BZ 18018, fixed in 2.28
# by commit 5aad5f617892 (an ancestor of the shipped srcrev).
CVE_STATUS[CVE-2011-0536] = "fixed-version: fixed in 2.28 (glibc BZ 18018, commit 5aad5f617892); shipped 2.43"
